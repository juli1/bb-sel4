## bb-eth/Kconfig
```kconfig
config APP_BBETH
    bool "Beaglebone Ethernet test"
    default n
        help
            Test for the ethernet driver
```
